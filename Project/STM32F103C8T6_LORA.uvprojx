# Keil uVision project STM32F103C8T6_LORA.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103C8T6_LORA +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Drive;..\User;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS;..\Libraries\CMSIS\startup
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../User/: app_scheduler.c app_scheduler.h debug.h lora.c lora.h loraSet.h main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h test.c test.h gprs.c gprs.h mbus.c mbus.h profile.c profile.h
  group DRIVE
    ../Drive/: hardware.h timer.c timer.h uart.c uart.h usually.c usually.h sys_tick_timer.c sys_tick_timer.h
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_usart.c
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group DOC
    ../Doc/: READEME.txt
